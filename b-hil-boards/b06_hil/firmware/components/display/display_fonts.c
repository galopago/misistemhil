#include "display_fonts.h"

#include <string.h>

#define FONT_BASE_WIDTH 6
#define FONT_BASE_HEIGHT 8

static const uint8_t FONT_BASE_GLYPHS[95][8] = {
    /* ' ' */ {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    /* '!' */ {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x00, 0x04},
    /* '"' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '#' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '$' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '%' */ {0x19, 0x1A, 0x04, 0x08, 0x16, 0x13, 0x00, 0x00},
    /* '&' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* quote */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '(' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* ')' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '*' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '+' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* ',' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '-' */ {0x00, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00},
    /* '.' */ {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04},
    /* '/' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '0' */ {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E, 0x00},
    /* '1' */ {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E, 0x00},
    /* '2' */ {0x0E, 0x11, 0x01, 0x06, 0x08, 0x10, 0x1F, 0x00},
    /* '3' */ {0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E, 0x00},
    /* '4' */ {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02, 0x00},
    /* '5' */ {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E, 0x00},
    /* '6' */ {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E, 0x00},
    /* '7' */ {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08, 0x00},
    /* '8' */ {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E, 0x00},
    /* '9' */ {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C, 0x00},
    /* ':' */ {0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x00},
    /* ';' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '<' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '=' */ {0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00},
    /* '>' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* '?' */ {0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04, 0x00},
    /* '@' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* 'A' */ {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11, 0x00},
    /* 'B' */ {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E, 0x00},
    /* 'C' */ {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E, 0x00},
    /* 'D' */ {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x00},
    /* 'E' */ {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F, 0x00},
    /* 'F' */ {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10, 0x00},
    /* 'G' */ {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F, 0x00},
    /* 'H' */ {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11, 0x00},
    /* 'I' */ {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E, 0x00},
    /* 'J' */ {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C, 0x00},
    /* 'K' */ {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11, 0x00},
    /* 'L' */ {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x00},
    /* 'M' */ {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11, 0x00},
    /* 'N' */ {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11, 0x00},
    /* 'O' */ {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E, 0x00},
    /* 'P' */ {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10, 0x00},
    /* 'Q' */ {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D, 0x00},
    /* 'R' */ {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11, 0x00},
    /* 'S' */ {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E, 0x00},
    /* 'T' */ {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00},
    /* 'U' */ {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E, 0x00},
    /* 'V' */ {0x11, 0x11, 0x11, 0x11, 0x0A, 0x0A, 0x04, 0x00},
    /* 'W' */ {0x11, 0x11, 0x11, 0x15, 0x15, 0x1B, 0x11, 0x00},
    /* 'X' */ {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11, 0x00},
    /* 'Y' */ {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04, 0x00},
    /* 'Z' */ {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F, 0x00},
    /* '[' */ {0x0E, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0E, 0x00},
    /* '\\' */ {0x04, 0x00, 0x04, 0x04, 0x08, 0x10, 0x0D, 0x00},
    /* ']' */ {0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x0E, 0x00},
    /* '^' */ {0x04, 0x0A, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00},
    /* '_' */ {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00},
    /* '`' */ {0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    /* 'a' */ {0x00, 0x00, 0x0E, 0x01, 0x0F, 0x11, 0x0F, 0x00},
    /* 'b' */ {0x10, 0x10, 0x1E, 0x11, 0x11, 0x11, 0x1E, 0x00},
    /* 'c' */ {0x00, 0x00, 0x0E, 0x11, 0x10, 0x11, 0x0E, 0x00},
    /* 'd' */ {0x01, 0x01, 0x0F, 0x11, 0x11, 0x11, 0x0F, 0x00},
    /* 'e' */ {0x00, 0x00, 0x0E, 0x11, 0x1F, 0x10, 0x0E, 0x00},
    /* 'f' */ {0x06, 0x09, 0x08, 0x1C, 0x08, 0x08, 0x08, 0x00},
    /* 'g' */ {0x00, 0x00, 0x0F, 0x11, 0x0F, 0x01, 0x0E, 0x00},
    /* 'h' */ {0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00},
    /* 'i' */ {0x04, 0x00, 0x0C, 0x04, 0x04, 0x04, 0x0E, 0x00},
    /* 'j' */ {0x02, 0x00, 0x06, 0x02, 0x02, 0x12, 0x0C, 0x00},
    /* 'k' */ {0x10, 0x10, 0x12, 0x14, 0x18, 0x14, 0x12, 0x00},
    /* 'l' */ {0x0C, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E, 0x00},
    /* 'm' */ {0x00, 0x00, 0x1A, 0x15, 0x15, 0x11, 0x11, 0x00},
    /* 'n' */ {0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00},
    /* 'o' */ {0x00, 0x00, 0x0E, 0x11, 0x11, 0x11, 0x0E, 0x00},
    /* 'p' */ {0x00, 0x00, 0x1E, 0x11, 0x1E, 0x10, 0x10, 0x00},
    /* 'q' */ {0x00, 0x00, 0x0F, 0x11, 0x0F, 0x01, 0x01, 0x00},
    /* 'r' */ {0x00, 0x00, 0x16, 0x19, 0x10, 0x10, 0x10, 0x00},
    /* 's' */ {0x00, 0x00, 0x0F, 0x10, 0x0E, 0x01, 0x1E, 0x00},
    /* 't' */ {0x08, 0x08, 0x1C, 0x08, 0x08, 0x09, 0x06, 0x00},
    /* 'u' */ {0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x0D, 0x00},
    /* 'v' */ {0x00, 0x00, 0x11, 0x11, 0x11, 0x0A, 0x04, 0x00},
    /* 'w' */ {0x00, 0x00, 0x11, 0x11, 0x15, 0x15, 0x0A, 0x00},
    /* 'x' */ {0x00, 0x00, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x00},
    /* 'y' */ {0x00, 0x00, 0x11, 0x11, 0x0F, 0x01, 0x0E, 0x00},
    /* 'z' */ {0x00, 0x00, 0x1F, 0x02, 0x04, 0x08, 0x1F, 0x00},
    /* '{' */ {0x06, 0x08, 0x08, 0x10, 0x08, 0x08, 0x06, 0x00},
    /* '|' */ {0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00},
    /* '}' */ {0x0C, 0x02, 0x02, 0x01, 0x02, 0x02, 0x0C, 0x00},
    /* '~' */ {0x00, 0x08, 0x15, 0x02, 0x00, 0x00, 0x00, 0x00},
};

static const display_font_t FONT_TABLE[DISPLAY_FONT_CLASS_COUNT] = {
    {
        .class_id = DISPLAY_FONT_CLASS_SMALL,
        .glyph_width = 6,
        .glyph_height = 8,
        .visual_height = 8,
    },
    {
        .class_id = DISPLAY_FONT_CLASS_MEDIUM,
        .glyph_width = 8,
        .glyph_height = 12,
        .visual_height = 12,
    },
    {
        .class_id = DISPLAY_FONT_CLASS_LARGE,
        .glyph_width = 12,
        .glyph_height = 16,
        .visual_height = 16,
    },
};

static int clamp_int(int value, int min_value, int max_value)
{
    if (value < min_value) {
        return min_value;
    }
    if (value > max_value) {
        return max_value;
    }
    return value;
}

static const uint8_t *font_glyph_rows(char ch)
{
    const unsigned char uch = (unsigned char)ch;
    if (uch < DISPLAY_ASCII_MIN || uch > DISPLAY_ASCII_MAX) {
        return FONT_BASE_GLYPHS['?' - DISPLAY_ASCII_MIN];
    }
    return FONT_BASE_GLYPHS[uch - DISPLAY_ASCII_MIN];
}

static void draw_scaled_glyph(display_canvas_t *canvas, int x, int y, char ch,
                              const display_font_t *font, uint8_t color)
{
    const uint8_t *rows = font_glyph_rows(ch);
    const int scale_x = font->glyph_width / FONT_BASE_WIDTH;
    const int scale_y = font->glyph_height / FONT_BASE_HEIGHT;

    for (int row = 0; row < FONT_BASE_HEIGHT; ++row) {
        const uint8_t row_bits = rows[row];
        for (int col = 0; col < FONT_BASE_WIDTH; ++col) {
            if ((row_bits & (1U << (FONT_BASE_WIDTH - 1 - col))) == 0) {
                continue;
            }
            const int px = x + col * scale_x;
            const int py = y + row * scale_y;
            display_canvas_fill_rect(canvas, px, py, scale_x, scale_y, color);
        }
    }
}

char display_font_sanitize_char(char ch)
{
    const unsigned char uch = (unsigned char)ch;
    if (uch < DISPLAY_ASCII_MIN || uch > DISPLAY_ASCII_MAX) {
        return '?';
    }
    return ch;
}

const display_font_t *display_font_get(display_font_class_t class_id)
{
    if (class_id < 0 || class_id >= DISPLAY_FONT_CLASS_COUNT) {
        return &FONT_TABLE[0];
    }
    return &FONT_TABLE[class_id];
}

const display_font_t *display_font_select(display_font_policy_t policy, int band_height)
{
    const display_font_t *candidates[DISPLAY_FONT_CLASS_COUNT] = {
        &FONT_TABLE[0],
        &FONT_TABLE[1],
        &FONT_TABLE[2],
    };

    const display_font_t *preferred = NULL;
    switch (policy) {
    case DISPLAY_FONT_SMALL:
        for (int i = DISPLAY_FONT_CLASS_COUNT - 1; i >= 0; --i) {
            if (candidates[i]->class_id == DISPLAY_FONT_CLASS_SMALL &&
                candidates[i]->visual_height <= band_height) {
                preferred = candidates[i];
                break;
            }
        }
        if (preferred == NULL) {
            preferred = &FONT_TABLE[0];
        }
        break;
    case DISPLAY_FONT_MEDIUM:
        for (int i = DISPLAY_FONT_CLASS_COUNT - 1; i >= 0; --i) {
            if (candidates[i]->class_id == DISPLAY_FONT_CLASS_MEDIUM &&
                candidates[i]->visual_height <= band_height) {
                preferred = candidates[i];
                break;
            }
        }
        if (preferred == NULL) {
            preferred = &FONT_TABLE[0];
        }
        break;
    case DISPLAY_FONT_LARGE:
        for (int i = DISPLAY_FONT_CLASS_COUNT - 1; i >= 0; --i) {
            if (candidates[i]->class_id == DISPLAY_FONT_CLASS_LARGE &&
                candidates[i]->visual_height <= band_height) {
                preferred = candidates[i];
                break;
            }
        }
        if (preferred == NULL) {
            preferred = &FONT_TABLE[0];
        }
        break;
    default:
        for (int i = DISPLAY_FONT_CLASS_COUNT - 1; i >= 0; --i) {
            if (candidates[i]->visual_height <= band_height) {
                preferred = candidates[i];
                break;
            }
        }
        break;
    }

    if (preferred != NULL) {
        return preferred;
    }

    return &FONT_TABLE[0];
}

display_text_metrics_t display_font_measure_text(const char *text, const display_font_t *font)
{
    display_text_metrics_t metrics = {
        .width = 0,
        .height = font == NULL ? 0 : font->glyph_height,
    };

    if (text == NULL || font == NULL) {
        return metrics;
    }

    const size_t len = strlen(text);
    metrics.width = (int)len * font->glyph_width;
    return metrics;
}

void display_font_draw_text(display_canvas_t *canvas, int x, int y, const char *text,
                            const display_font_t *font, uint8_t color)
{
    if (canvas == NULL || text == NULL || font == NULL) {
        return;
    }

    int cursor_x = x;
    for (const char *p = text; *p != '\0'; ++p) {
        draw_scaled_glyph(canvas, cursor_x, y, display_font_sanitize_char(*p), font, color);
        cursor_x += font->glyph_width;
    }
}

void display_font_truncate_to_width(char *text, size_t text_capacity, const display_font_t *font,
                                    int max_width)
{
    if (text == NULL || font == NULL || text_capacity == 0) {
        return;
    }

    size_t len = strlen(text);
    while (len > 0) {
        text[len] = '\0';
        if (display_font_measure_text(text, font).width <= max_width) {
            return;
        }
        len--;
    }
    text[0] = '\0';
}
